# Keil uVision project APP.uvprojx, settings and files
target APP (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FreeRTOS\include;.\STDriver\inc;.\UserDriver\Inc;.\GUI;.\GUI_Config;.\LCD_Driver;.\GUI\Core;.\GUI\WM;.\GUI\AntiAlias;.\GUI\ConvertColor;.\GUI\Font;.\GUI\JPEG;.\GUI\MultiLayer;.\GUI\Widget;.\FatFS13\ff13;.\Tests;.\Mavlink;.\Mavlink\common;.\UserDriver\Src;.\MavlinkV1;.\MavlinkV1\common;.\MavlinkV1\ardupilotmega;.\MavlinkV1\joyton;.\Joytonlink
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_md.s
    ./CMSIS/: stm32f10x_it.c
  group STDriver
    ./STDriver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_sdio.c
  group UserDriver
    ./UserDriver/Src/: stm32f10x_driver.c timer.c user_tasks.c led.c main.c usart.c runtime.c
    ./STDriver/src/: stm32f10x_iwdg.c
    ./UserDriver/Inc/: joylink_msg_test.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group MavlinkV1
    ./MavlinkV1/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h user_pixhawk_type.h protocol.h
    ./MavlinkV1/common/: mavlink_msg_heartbeat.h mavlink_msg_system_time.h mavlink_msg_vfr_hud.h mavlink_msg_global_position_int.h mavlink_msg_nav_controller_output.h mavlink_msg_command_long.h mavlink_msg_attitude.h mavlink_msg_sys_status.h mavlink_msg_gps_raw_int.h mavlink_msg_power_status.h mavlink_msg_mission_current.h mavlink_msg_command_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_item.h mavlink_msg_mission_request.h mavlink_msg_mission_request_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_ack.h mavlink_msg_scaled_pressure.h common.h mavlink_msg_set_mode.h mavlink_msg_gps_global_origin.h mavlink_msg_home_position.h mavlink_msg_set_position_target_local_ned.h mavlink_msg_set_position_target_global_int.h mavlink_msg_set_attitude_target.h mavlink_msg_camera_trigger.h mavlink_msg_mission_item_int.h mavlink_msg_distance_sensor.h
    ./MavlinkV1/ardupilotmega/: mavlink_msg_data16.h ardupilotmega.h mavlink_msg_gcs_control_code.h mavlink_msg_data64.h mavlink_msg_camera_feedback.h
  group Joytonlink
    ./Joytonlink/: Joylink.h joylink_common.h joylink_defines.h joylink_msg_attitude.h joylink_msg_camera_feedback.h joylink_msg_camera_trigger.h joylink_msg_command.h joylink_msg_command_ack.h joylink_msg_fly_status.h joylink_msg_gps_position.h joylink_msg_gps_raw.h joylink_msg_heartbeat.h joylink_msg_home_position.h joylink_msg_landing_target.h joylink_msg_mission_ack.h joylink_msg_mission_clear_all.h joylink_msg_mission_count.h joylink_msg_mission_current.h joylink_msg_mission_element.h joylink_msg_mission_item_reached.h joylink_msg_mission_request.h joylink_msg_mission_request_list.h joylink_msg_mission_set_current.h joylink_msg_nav_controller_output.h joylink_msg_power_status.h joylink_msg_pressure.h joylink_msg_rangefinder.h joylink_msg_rc_channels_override.h joylink_msg_request_send_data.h joylink_msg_set_attitude_target.h joylink_msg_set_home_position.h joylink_msg_set_mode.h joylink_msg_set_position_target_global_int.h joylink_msg_system_time.h
